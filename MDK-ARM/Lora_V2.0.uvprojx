# Keil uVision project Lora_V2.0.uvprojx, settings and files
target Lora_V2.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Lora_V2.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,EBYTE_E32_900M20S
  c include: ../Core/Inc;  ../USB_DEVICE/App;  ../USB_DEVICE/Target;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;  ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include;  ..\Core\User;  ..\Middlewares\Lora\1_Middleware\Kfifo;  ..\Middlewares\Lora\1_Middleware\Produce;  ..\Middlewares\Lora\2_Ebyte_Board_Support\E15-EVB02;  ..\Middlewares\Lora\3_Ebyte_WirelessModule_Drivers\E32xMx;  ..\Middlewares\Lora\3_Ebyte_WirelessModule_Drivers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/User/: ws281x.c
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c iwdg.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/Lora
    ../Middlewares/Lora/1_Middleware/Kfifo/: ebyte_kfifo.c
    ../Middlewares/Lora/1_Middleware/Produce/: ebyte_debug.c
    ../Middlewares/Lora/2_Ebyte_Board_Support/E15-EVB02/: board.c board_button.c board_mini_printf.c
    ../Middlewares/Lora/3_Ebyte_WirelessModule_Drivers/E32xMx/: ebyte_callback.c ebyte_e32x.c ebyte_port.c
    ../Middlewares/Lora/3_Ebyte_WirelessModule_Drivers/: ebyte_core.c
software components: CMSIS:CORE 4.3.0
